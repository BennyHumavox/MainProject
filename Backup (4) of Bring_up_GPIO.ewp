# IAR project Backup (4) of Bring_up_GPIO.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F128.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\common; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\target\CC2530EB; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\high_level; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level\srf04\single_chip; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level\srf04\; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\osal\common; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\osal\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\services\saddr; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\services\sdata
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2531F128.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Bring_up_GPIO.c
