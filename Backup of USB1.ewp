# IAR project Backup of USB1.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: MAKE_CRC_SHDW; NV_INIT; NV_RESTORE; OSAL_SAPI=FALSE; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_NWK_FUNC; MT_NWK_CB_FUNC; MT_AF_FUNC; MT_AF_CB_FUNC; MT_USER_TEST_FUNC; MT_ZDO_FUNC; MT_ZDO_CB_FUNC; MT_ZDO_MGMT; MT_SAPI_FUNC; MT_SAPI_CB_FUNC; MT_UTIL_FUNC; MT_APP_FUNC; REFLECTOR; HOLD_AUTO_START; xLCD_SUPPORTED=DEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\common; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\target\CC2530USB; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\target\CC2530USB\usb\library\cc2531; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\target\CC2530USB\usb\library\; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\hal\target\CC2530USB\usb\class_cdc; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\high_level; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level\srf04\single_chip; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\mac\low_level\srf04\; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\osal\common; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\osal\include; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\services\saddr; C:\Texas Instruments\TIMAC-CC2530-1.4.0\Components\services\sdata
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: USB1.c
